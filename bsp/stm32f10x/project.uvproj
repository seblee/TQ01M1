# Keil uVision project project.uvproj, settings and files
target rtthread-stm32 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread +hex
  AfterMake: fromelf --bin !L -o ./rtthread.bin
  c flags: OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: applications;.;drivers;Libraries\STM32F10x_StdPeriph_Driver\inc;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32_Cryptographic_Library\inc;..\..\components\CMSIS\Include;..\..\include;..\..\libcpu\arm\cortex-m3;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\filesystems\elmfat;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\components\net\at\include;..\..\components\net\at\at_socket;.\FreeModbus\modbus\include;.\FreeModbus\port;.\FreeModbus\modbus\rtu;.\usr\modules;.\kits;.\FreeModbus\port\modbus_monitor_slave;.\paho.mqtt.embedded-c\MQTTPacket\src;.\sim7600;.\sim7600\SIM_COM;.\cJSON;..\..\components\net\sal_socket\include;..\..\components\net\sal_socket\include\socket;..\..\components\net\sal_socket\impl;..\..\components\net\sal_socket\include\dfs_net;..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\components\net\sal_socket\include\socket\sys_socket
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x3d000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: startup.c application.c
    ./applications/: global_var.c
    ./: readme.txt
  group threads
    ./usr/threads/: cpad_thread.c daq_thread.c core_thread.c surv_thread.c testcase_thread.c team_thread.c bkg_thread.c
  group usr
    ./usr/modules/: syslog.c authentication.c require_calc.c alarm_calc.c output_ctrl.c req_execution.c event_record.c daq.c sys_status.c team.c password.c reg_map_check.c
  group Drivers
    ./drivers/: adc_bsp.c dio_bsp.c cpad_bsp.c can_bsp.c usart_bsp.c pwm_bsp.c led_bsp.c rtc_bsp.c i2c_bsp.c watchdog_bsp.c TH_Sensor_Bsp.c Moter.c
    drivers/: board.c stm32f10x_it.c
    ./Libraries/STM32_Cryptographic_Library/binary/MK-ARM/: M3_CryptoFW_2_0_6.lib
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    ../../components/init/: components.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group kits
    ./kits/: fifo.c calc.c cyc_buff.c Delay.c
  group modbus_slave
    ./FreeModbus/port/: port.c portevent.c portserial.c porttimer.c user_mb_app.c
    ./FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ./FreeModbus/modbus/functions/: mbfuncholding.c mbutils.c mbfuncother.c
    ./FreeModbus/modbus/: mb.c
  group modbus_master
    ./FreeModbus/port/: portevent_m.c portserial_m.c porttimer_m.c user_mb_app_m.c
    ./FreeModbus/modbus/rtu/: mbrtu_m.c
    ./FreeModbus/modbus/functions/: mbfuncholding_m.c
    ./FreeModbus/modbus/: mb_m.c
  group modbus_monitor
    ./FreeModbus/port/modbus_monitor_slave/: mb_event_cpad.c portserial_cpad.c porttimer_cpad.c user_mb_app_cpad.c
  group Network
    ./sim7600/: transport.c at_transfer.c mqtt_client.c utils_hmac.c utils_md5.c disguise_time.c network.c
    ./cJSON/: cJSON.c
  group MQTTPacket
    ./paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group SIM_COM
    ./sim7600/SIM_COM/: SIMCOM_AT.c SIMCOM_GSM.c SIMCOM_USER.c SIMCOM_GPRS.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../components/libc/compilers/common/: gmtime_r.c
  group AT
    ../../components/net/at/at_socket/: at_socket.c
    ../../components/net/at/src/: at_utils.c at_client.c
  group SAL
    ../../components/net/sal_socket/src/: sal_ipaddr.c sal_socket.c
    ../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal_socket/impl/: af_inet_at.c
    ../../components/net/sal_socket/dfs_net/: dfs_net.c
